DSEG AT 30H
STR: DS 7

CSEG AT 0

MOV R7,#2
MOV R6,#1
MOV A,#'0'
MOV 38H,A

L1:
MOV A,R7
MOV B,R6
MUL AB
;MOV R1,B
MOV B,#10
DIV AB
MOV R2,A
MOV R0,#STR
MOV A,R7
ORL A,#'0'
MOV @R0,A
INC R0
MOV A,#'x'
MOV @R0,A
INC R0
MOV A,R6
DA A
JB ACC.4,L2

L3:
ORL A,#'0'
MOV @R0,A
MOV 39H,A
INC R0
MOV A,#'='
MOV @R0,A
INC R0
MOV A,R2
ORL A,#'0'
MOV @R0,A
INC R0
MOV A,B
ORL A,#'0'
MOV @R0,A


INC R6
;SJMP L1
ACALL DELAY
L5:
CJNE R6,#11,L1
SJMP $

L2:
MOV R3,A
SWAP A
ANL A,#0FH
ORL A,#'0'
MOV @R0,A
MOV 38H,A
INC R0
MOV A,R3
ANL A,#0FH
SJMP L3

DELAY:
MOV R2,#2
DL3:
MOV R3,#255
DL2:
MOV R4,#255
DL1:
MOV R5,#255
DJNZ R5,$
DJNZ R4,DL1
DJNZ R3,DL2
DJNZ R2,DL3
SJMP L5
;RET

END
